# Repository DanielYJHsieh/esp32c3

File README.md:

# ESP32-C3 Projects

這是 ESP32-C3 的開發專案集合，使用 ESP-IDF v5.5.1 框架。本 repository 包含多個實用專案，從基礎入門到進階應用，幫助你快速開始 ESP32-C3 開發。

## 🎯 你可以做什麼？ What Can I Do?

使用這個 repository，你可以：

1. **🚀 快速入門**: 從 `blink` 和 `hello_world` 開始，學習 ESP32-C3 基礎
2. **🖥️ E-Paper 顯示**: 使用 `esp32c3_spi_display` 驅動 4.26" E-Paper 顯示器
3. **📡 WiFi 應用**: 透過 `esp32c3_wifi_display` 和 `esp32c3_wifi_led_control` 學習 WiFi 連接和網頁控制
4. **🔋 電池管理**: 使用 `battery_management` 打造低功耗、長續航的電池供電裝置
5. **💡 物聯網專案**: 結合以上技術，開發自己的 IoT 應用

## 📚 專案列表

### 1. blink
**基礎 LED 閃爍測試專案**

- 適合初學者的第一個專案
- 學習 GPIO 控制和 LED 驅動
- 支援普通 LED 和可程式化 LED（如 WS2812）

[查看詳細說明](blink/README.md)

---

### 2. hello_world
**Hello World 基礎測試專案**

- ESP32-C3 的入門專案
- 學習 FreeRTOS 任務和串口輸出
- 驗證開發環境是否正確設定

[查看詳細說明](hello_world/README.md)

---

### 3. esp32c3_spi_display
**E-Paper 顯示器驅動專案** ⭐

使用 ESP32-C3 驅動 GDEQ0426T82 E-Paper 顯示器，適合製作電子標籤、資訊看板等低功耗顯示應用。

- **顯示器**: GDEQ0426T82 (4.26" 800x480)
- **控制器**: SSD1677
- **通訊介面**: SPI (4MHz, Mode 0)

#### 功能特色
- ✅ 完整的 E-Paper 驅動程式
- ✅ 全螢幕更新 (1610ms)
- ✅ 部分更新 (410ms)
- ✅ 圖形繪製功能 (點、線、矩形、填充)
- ✅ 文字渲染系統 (ASCII + 中文字體)
- ✅ 網格測試模式

#### 硬體連接
```
ESP32-C3    E-Paper
GPIO2   ->  SCLK
GPIO3   ->  MOSI
GPIO10  ->  CS
GPIO4   ->  DC
GPIO5   ->  RST
GPIO6   ->  BUSY
```

#### 記憶體使用
- Flash: 240KB / 1MB (23%)
- RAM: 48KB framebuffer + 應用程式

[查看詳細說明](esp32c3_spi_display/README.md)

---

### 4. esp32c3_wifi_display
**WiFi E-Paper 顯示器專案** ⭐

結合 WiFi 功能與 E-Paper 顯示器，可透過網頁介面上傳圖片並顯示。適合製作智能資訊看板、照片牆等應用。

#### 功能特色
- ✅ WiFi 連接和 HTTP 服務器
- ✅ 網頁介面上傳圖片
- ✅ E-Paper 顯示器驅動 (800x480)
- ✅ 全螢幕和部分更新
- ✅ RESTful API

#### 使用情境
- 遠端更新電子標籤
- 智能家庭資訊看板
- 照片展示裝置

[查看詳細說明](esp32c3_wifi_display/README.md)

---

### 5. esp32c3_wifi_led_control
**WiFi LED 控制專案**

透過 WiFi 網頁介面控制 LED，學習基礎的 IoT 控制應用。

#### 功能特色
- ✅ WiFi 連接
- ✅ 網頁控制介面
- ✅ LED 開關控制
- ✅ RESTful API

#### 應用場景
- 遠端燈光控制
- 智能家居原型
- IoT 學習專案

[查看詳細說明](esp32c3_wifi_led_control/README.md)

---

### 6. battery_management
**電池供電與充放電管理系統** ⭐⭐

為 ESP32-C3 SuperMini 開發板提供完整的電池供電解決方案，使用 TP4054 充電 IC + MOSFET 自動切換架構。

#### 設計特點
- ✅ 極致小型化（~10×15mm，比模組小 60%）
- ✅ P-MOSFET 自動切換（效率 >99%，壓降僅 0.02V）
- ✅ N-MOSFET 省電 ADC 監測（平時 0μA）
- ✅ 充電電流可調（推薦 130mA）
- ✅ 超長續航（500mAh 電池可用 2-3 個月）
- ✅ Deep Sleep 功耗 < 5.5μA

#### 適用場景
- 低功耗 IoT 裝置
- 電池供電的感測器
- 便攜式電子裝置
- E-Paper 顯示器專案

#### ESP32-C3 vs ESP8266 電源優勢
- **Deep Sleep 電流**: 5μA（ESP8266: 20μA）- 省電 4 倍
- **ADC 解析度**: 12-bit（ESP8266: 10-bit）- 更精確的電量監測
- **ULP 協處理器**: 支援後台處理，ESP8266 無此功能

[查看詳細說明](battery_management/README.md)

---

## 🚀 快速開始

### 前置需求

- **ESP-IDF**: v5.5.1
- **工具鏈**: riscv32-esp-elf-gcc 14.2.0
- **目標晶片**: ESP32-C3 (RISC-V)
- **硬體**: ESP32-C3 SuperMini 開發板或其他 ESP32-C3 開發板

### 安裝 ESP-IDF

請參考 [ESP-IDF 安裝指南](https://docs.espressif.com/projects/esp-idf/en/latest/esp32c3/get-started/index.html)

### 編譯與燒錄

```bash
# 1. 設定 ESP-IDF 環境
. $HOME/esp/esp-idf/export.sh  # Linux/macOS
# 或
C:\Users\<username>\esp\v5.5.1\esp-idf\export.ps1  # Windows PowerShell

# 2. 進入專案目錄（以 blink 為例）
cd blink

# 3. 設定目標晶片（首次）
idf.py set-target esp32c3

# 4. 編譯
idf.py build

# 5. 燒錄（請將 COM4 替換為你的串口）
idf.py -p COM4 flash

# 6. 監控輸出
idf.py -p COM4 monitor

# 或者合併步驟 5 和 6
idf.py -p COM4 flash monitor
```

### 串口設定

- **Windows**: 通常是 `COM3`, `COM4` 等
- **Linux**: 通常是 `/dev/ttyUSB0`, `/dev/ttyUSB1` 等
- **macOS**: 通常是 `/dev/cu.usbserial-xxx`

查看串口：
```bash
# Windows (PowerShell)
[System.IO.Ports.SerialPort]::getportnames()

# Linux
ls /dev/ttyUSB*

# macOS
ls /dev/cu.*
```

## 🎓 學習路徑建議

### 初學者（第 1-2 週）
1. 從 **hello_world** 開始，熟悉開發環境
2. 嘗試 **blink** 專案，學習 GPIO 控制
3. 閱讀 ESP-IDF 基礎文檔

### 進階學習（第 3-4 週）
4. 學習 **esp32c3_wifi_led_control**，掌握 WiFi 連接
5. 嘗試修改網頁介面，增加功能

### 實作專案（第 5-8 週）
6. 挑戰 **esp32c3_spi_display**，驅動 E-Paper 顯示器
7. 進階到 **esp32c3_wifi_display**，結合 WiFi 和顯示器
8. 研究 **battery_management**，打造低功耗裝置

### 獨立開發（第 9 週+）
9. 結合多個專案的技術，開發自己的 IoT 應用
10. 分享你的專案成果！

## 💡 專案組合建議

### 組合 1：智能電子標籤
- **esp32c3_wifi_display** + **battery_management**
- 適合製作可遠端更新、電池供電的電子標籤
- 續航時間：2-3 個月（每日更新 2 次）

### 組合 2：智能家居控制中心
- **esp32c3_wifi_led_control** + 自訂感測器
- 透過網頁控制家中裝置
- 可擴展加入溫濕度、人體感應等功能

### 組合 3：離線資訊顯示
- **esp32c3_spi_display** + **battery_management**
- 顯示天氣、日曆、待辦事項等
- 超低功耗，適合長期使用

## 📖 文件資源

### 官方文件
- [ESP32-C3 技術參考手冊](docs/esp32-c3_technical_reference_manual_en.pdf)
- [ESP32-C3 數據手冊](docs/esp32_c3_datasheet.pdf)
- [ESP-IDF 程式設計指南](https://docs.espressif.com/projects/esp-idf/en/latest/esp32c3/)

### 硬體資源
- [ESP32-C3 SuperMini 電路圖](docs/esp32-c3-supermini-schematic.png)
- [ESP32-C3 SuperMini 腳位圖](docs/esp32_c3_supermini_pinout.jpg)
- 元件規格書：查看 `docs/` 目錄

## 🛠️ 開發工具推薦

- **IDE**: Visual Studio Code + ESP-IDF 擴充功能
- **串口工具**: PuTTY, minicom, 或 `idf.py monitor`
- **版本控制**: Git
- **電路圖**: KiCad, EasyEDA

## ❓ 常見問題

### Q1: 燒錄失敗怎麼辦？
**A**: 
1. 確認串口正確（`idf.py -p COM4 flash`）
2. 按住 BOOT 按鈕，按一下 RESET 按鈕，然後放開 BOOT
3. 檢查 USB 線材是否支援數據傳輸
4. 嘗試降低波特率：`idf.py -p COM4 -b 115200 flash`

### Q2: 編譯錯誤怎麼辦？
**A**:
1. 確認 ESP-IDF 版本是 v5.5.1
2. 執行 `idf.py fullclean` 清除建置檔案
3. 重新編譯：`idf.py build`
4. 檢查是否缺少相依套件

### Q3: WiFi 連接失敗？
**A**:
1. 檢查 WiFi 帳號密碼是否正確
2. 確認路由器支援 2.4GHz（ESP32-C3 不支援 5GHz）
3. 查看串口輸出的錯誤訊息
4. 嘗試重置 WiFi 設定：`idf.py erase-flash`

### Q4: E-Paper 顯示器沒反應？
**A**:
1. 檢查接線是否正確（參考專案 README）
2. 確認 E-Paper 型號是否正確（GDEQ0426T82）
3. 檢查 BUSY 腳位是否正常（高電平表示正在更新）
4. 嘗試全螢幕更新而非部分更新

### Q5: 如何降低功耗？
**A**:
1. 使用 Deep Sleep 模式（參考 battery_management）
2. 關閉不需要的週邊設備（WiFi, BLE）
3. 降低 CPU 頻率
4. 參考 [ESP32-C3 低功耗模式指南](docs/ESP32C3_POWER_FEATURES.md)

## 🤝 貢獻

歡迎提出 Issue 或 Pull Request！

如果你有：
- 🐛 發現 Bug
- 💡 新功能建議
- 📝 文件改進
- 🎨 範例程式碼

請隨時開啟 Issue 討論或直接提交 PR。

## 📝 版本歷史

- **v1.0** (2025-10-28)
  - 完成 E-Paper 驅動程式
  - 實現圖形繪製功能
  - 加入中英文字體系統
  - 加入網格測試模式
  - 新增電池管理系統文檔

## 📄 授權

MIT License

---

## 📧 聯絡方式

如有任何問題或建議，請透過 GitHub Issues 聯繫。

---

**祝你開發順利！Happy Coding! 🎉**

## KiCad design EPD24_Mini_Adapter_HW/kicad/EPD24_Mini_Adapter.kicad_pcb

File EPD24_Mini_Adapter_HW/README.md:

# EPD24 Mini 轉接板 v1.1（DESPI-C02 縮小版，排線接 MCU）

取代 Good Display DESPI-C02（41 × 22 mm）的獨立小轉接板，驅動 24pin SPI 電子紙（目前用 GDEQ0426T82，SSD1677），板子放在面板旁邊，用 **8 條線直接焊**到 J2，拉到 ESP32-C3 Super Mini（或任何 3.3V MCU）。

- 板子 **18.0 × 19.9 mm**（DESPI-C02 的約 40%）
- 雙層、零件全在單面（F 面）。**JLCPCB 只貼 Basic 料**（6 種 17 顆，不用換料費）；JLC 只有 Extended 料的 **J1 FPC 座、L1 電感、R2 0.47Ω 自己買料手焊**（見 `BOM.md` 第 2 節）
- e-paper 電路跟 `../EPD24_SuperMini_Adapter_HW` v1.0 相同（Q1、高壓電容換成 JLC Basic 料），只把 Super Mini 排針換成排線焊點；要直接疊在 Super Mini 上、或要電池電路，用那個專案

## 接頭

| 位置 | 接頭 | 說明 |
|---|---|---|
| 上緣 | J1：24P 0.5mm 翻蓋 FPC 座 | 面板排線從上緣插入 |
| 下緣 | J2：1×8 穿孔焊點，2.0mm 間距、孔徑 0.8mm（不貼片） | 線從孔穿過再焊，比表面焊盤耐拉；pin 1 方形焊墊，從零件面看在左邊 |

### J2 腳位與 Super Mini 接法

腳位順序同 DESPI-C02 的 8pin 排針，原本的接線說明可以直接沿用。Super Mini 這端的 GPIO 同 `esp32c3_spi_display`（`main/epaper_driver.h`）。

**注意**：`esp32c3_spi_display/PIN_MIGRATION.md` 已定案把 MOSI 從 IO3 改到 IO7（IO3 留給喚醒按鈕）。韌體改完後，J2 pin 3 SDI 要改接 **IO7**。

| J2 | 訊號 | ESP32-C3 Super Mini |
|---|---|---|
| 1 | 3.3V | 3.3 |
| 2 | GND | G |
| 3 | SDI (MOSI) | IO3（改腳位後 IO7） |
| 4 | SCLK | IO2 |
| 5 | CS | IO10 |
| 6 | D/C | IO4 |
| 7 | RES | IO5 |
| 8 | BUSY | IO6 |

板子背面印了腳位表，每個焊點上方也有標示（3V3 GND SDI SCK CS DC RES BSY）。

接線建議：
- 線長盡量 **20 cm 以內**；SCLK、SDI 旁邊最好有 GND 線（例如用 8 芯排線，GND 夾在中間），線長一點就把 SPI 時脈調低（例如 4 MHz）。
- 3V3、GND 用 26 AWG 以上；面板刷新時升壓電路瞬間電流較大。
- 焊好後用膠固定線材出口，避免拉扯焊點。

## 電路

照原廠原理圖 `DESPI-C02_SCH V1.0`（2018.07.06）。

| 項目 | DESPI-C02 | 本板 |
|---|---|---|
| RESE 電阻 | DIP 切 0.47Ω / 3Ω（新版 2.2Ω） | **固定 0.47Ω**（GDEQ0426T82 目前 DIP 撥 0.47） |
| BS | R4 3Ω 接地 + R5 10k 上拉 | 直接接地（4 線 SPI） |
| 二極體 | MBR0530（SOD-123） | B5819WS（SOD-323，40V 1A） |
| 電感 | 10µH 1A | 10µH、2520 封裝、Isat ≥ 1A |
| 高壓電容 | 4.7µF/25V | 4.7µF/25V **0805**（JLC Basic C1779） |
| 低壓電容 | 1µF/50V | 1µF/25V **0402**（VDD、VPP、VCOM、3V3 都在 10V 以下） |
| Q1 升壓開關 | Si1308EDL（SC-70） | **AO3400A**（SOT-23，30V 5.7A，JLC Basic） |
| 8pin 排針、DIP 開關、LDO | 有 | 拿掉；排針換成 8 個穿孔焊點 |

**換別的面板**要先查它規格書的 RESE 值；0.47Ω 不一定適用所有面板。

## 版本

- v1.0（2026-10-30）：JST SH 8P 座、Si1308EDL、0603 高壓電容，18 × 21.5 mm。沒有打樣，檔案在 git 歷史。
- v1.1（2026-11-01）：為了降低 JLC 換料費，J2 改成手焊焊點，Q1 改 AO3400A、高壓電容改 0805，Extended 料從 6 種降到 3 種；板長縮到 19.9 mm。剩下的 J1、L1、R2 也不給 JLC 貼，改手焊，貼片全部是 Basic 料。

## 驗證結果

- **DRC：0 違規、0 未連接**（JLCPCB 2 層標準製程：線寬／線距 ≥ 0.127 mm、過孔 0.5／0.3 mm、銅箔到板邊 ≥ 0.3 mm）
- **ERC：0 違規**
- **電路圖與 PCB 的 21 條網路逐條比對，完全一致**（`kicad/compare_nets.py`）
- 二極體方向已在 3D 預覽核對（D3 陰極接 PREVGH、D1 陰極接 NEG、D2 陰極接 GND）
- DRC 剩 1 個 connection_width **警告**（FPC pin 15/16 兩個 3V3 焊墊之間），實際銅寬 0.3 mm，判斷為 KiCad 誤判；不是錯誤
- 還沒打樣，沒有實際上電驗證

## 下單前要確認

1. **FPC 座的接觸面（上接 / 下接）**：BOM 選的 C262567（AFC07-S24FCA-00）是**下接**。拿現在那塊 DESPI-C02 對照，排線金手指朝哪面、FPC 座是哪一型。選錯的話腳位會整排反過來。
2. **FPC 座外形**：footprint 用 KiCad 內建的 `Jushuo_AFC07-S24FCA-00`。
3. **電感**：已選 Sunlord WPN252012H100MT（C98353，Isat 1.1A）。
4. **LCSC 料號已填**（2026-10-30 查 JLC 料庫）。上傳 BOM 後看缺料和 Basic / Extended 標示，缺料時照「規格」欄換同封裝。
5. JLCPCB 貼片預覽要檢查 **D1~D3 的方向**（陰極色帶）、**Q1 的旋轉角度**。J1、L1、R2、J2 不貼片，不會出現在 BOM / CPL（鋼網照樣會在這些焊墊上錫膏，回來是預上錫的狀態，手焊比較好焊）。
6. **手焊料**：J1（C262567）、L1（C98353）、R2（C423162）自己買，可以跟板子同一張 LCSC 訂單一起買，多買幾顆備用。

## 檔案

| 檔案 | 內容 |
|---|---|
| `EPD24_Mini_Adapter_v1.1_Gerber.zip` | Gerber + 鑽孔，直接上傳板廠 |
| `BOM.md` | 零件清單（貼片零件、另購料、挑料注意） |
| `BOM_JLCPCB_v1.1.csv` / `CPL_JLCPCB_v1.1.csv` | JLCPCB 貼片用 BOM、座標檔 |
| `EPD24_Mini_Adapter_schematic.pdf` | 電路圖 |
| `pcb_3d_top.png` / `pcb_3d_bottom.png` | 3D 預覽 |
| `kicad/` | KiCad 專案與產生程式 |

下單參數：2 層、FR-4、板厚 1.0mm 或 1.6mm 皆可、1oz、無鉛噴錫。

## 重新產生

在 `kicad/` 資料夾：

```bash
"D:\Program Files\KiCad\bin\python.exe" build_pcb.py --route
```

| 檔案 | 用途 |
|---|---|
| `build_pcb.py` | 放零件、網路、板框、絲印、設計規則、接地過孔（加 `--route` 會接著佈線；某條網路走不通會自動移到最前面重試） |
| `route.py` | 格點自動佈線（格點 0.05mm）、GND 縫合過孔、鋪銅 |
| `gen_sch.py` | 產生電路圖（`python gen_sch.py`） |
| `drc_summary.py` | 跑 DRC 並印摘要 |
| `compare_nets.py` | 電路圖網路表 vs PCB 比對（先 `kicad-cli sch export netlist -o sch.net`） |
| `export_fab.py` | 匯出 Gerber zip、BOM（CSV + `BOM.md`）、CPL、電路圖 PDF、3D 預覽 |

## 韌體備註

- `esp32c3_spi_display/main/epaper_driver.h` 的 `PIN_MISO` 和 `PIN_RST` 都設成 GPIO5。面板不需要 MISO，建議 SPI 設定改成 `miso_io_num = -1`，免得干擾 RES。

Parts:
C1, C2, C3, C5, C9, C10, C11: 4.7uF/25V; C_0805_2012Metric
C4: 4.7uF/10V; C_0402_1005Metric
C6, C7, C8, C12: 1uF/25V; C_0402_1005Metric
D1, D2, D3: B5819WS; D_SOD-323
J1: AFC07-S24FCA-00; Jushuo_AFC07-S24FCA-00_1x24-1MP_P0.50_Horizontal
J2: WIRE PADS; PinHeader_1x08_P2.00mm_Vertical
L1: 10uH Isat>=1A; L_1008_2520Metric
Q1: AO3400A; SOT-23
R1: 10k; R_0402_1005Metric
R2: 0.47R 1%; R_0402_1005Metric

Connections:
3V3: C4.1, C6.1, J1.15, J1.16, J2.1, L1.1
BUSY: J1.9, J2.8
CS: J1.12, J2.5
DC: J1.11, J2.6
GDR: J1.2, Q1.1 (G), R1.1
GND: C1.2, C2.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, D2.1 (K), J1.8, J1.17, J2.2, R1.2, R2.2
NEG: C3.2, D1.1 (K), D2.2 (A)
PREVGH: C5.1, D3.1 (K), J1.21
PREVGL: C11.1, D1.2 (A), J1.23
RES: J1.10, J2.7
RESE: J1.3, Q1.2 (S), R2.1
SCLK: J1.13, J2.4
SDI: J1.14, J2.3
SW: C3.1, D3.2 (A), L1.2, Q1.3 (D)
VCOM: C12.1, J1.24
VDD: C7.1, J1.18
VGH: C2.1, J1.5
VGL: C1.1, J1.4
VPP: C8.1, J1.19
VSH: C9.1, J1.20
VSL: C10.1, J1.22

Notes on the sheet:
面板 FPC：24P 0.5mm 翻蓋（腳位同 DESPI-C02）
pin 1 NC、6 TSCL、7 TSDA 不接；pin 8 BS 接地 = 4 線 SPI
排線焊點 J2：1x8 穿孔、2.0mm 間距，排線直接焊；腳位順序同 DESPI-C02 的 8pin
ESP32-C3 Super Mini 接法（同 esp32c3_spi_display / epaper_driver.h）：
1 3V3 → 3.3 2 GND → G 3 SDI → IO3（照 PIN_MIGRATION.md 改腳位後為 IO7） 4 SCLK → IO2
5 CS → IO10 6 DC → IO4 7 RES → IO5 8 BUSY → IO6
J2 不貼片，排線手焊
升壓 / 負壓泵（面板 IC 用 GDR、RESE 控制）
R2 = RESE 電流檢測，固定 0.47Ω（DESPI-C02 DIP 撥 0.47 那側，GDEQ0426T82 實測可用）
D1~D3 原廠 MBR0530（SOD-123）→ B5819WS（SOD-323，40V 1A）；Q1 原廠 Si1308EDL → AO3400A（SOT-23，JLC Basic）
面板電源電容（靠近 FPC 腳）
高壓腳（約 ±20V）用 0805 25V（JLC Basic）；低壓用 0402。原廠 1uF 為 50V，這裡腳位電壓都低於 10V，用 25V

Board: 2 copper layers, 18.0 x 19.9 mm, 21 parts (0 on the bottom side), 21 nets.

File EPD24_Mini_Adapter_HW/BOM.md:

# EPD24 Mini 轉接板 v1.1 — BOM（零件清單）

由 `kicad/export_fab.py` 從 PCB 產生，和 `BOM_JLCPCB_v1.1.csv`、`CPL_JLCPCB_v1.1.csv` 同步；改零件請改程式後重新產生。

- 貼片零件：**6 種、17 顆**，全部在 F 面，**都是 Basic 料（B5819WS 為 Preferred），不用付換料費**
- **J1、L1、R2 不貼片、自己手焊**（JLC 只有 Extended 料，每種換料費約 $3）；J2 是排線焊點
- **LCSC 料號已填**（2026-10-30 查 JLC 料庫，盡量用 Basic 料）。庫存會變，下單時若缺料，照「規格」欄換同封裝的料

## 1. 貼片零件

| 編號 | 值 | 封裝 | 數量 | 規格 | 型號 | LCSC | 用途 |
|---|---|---|---|---|---|---|---|
| C1, C2, C3, C5, C9, C10, C11 | 4.7uF/25V | C 0805 2012Metric | 7 | MLCC 0805 X5R 25V | Samsung CL21A475KAQNNNE | C1779 Basic | VGL、VGH、負壓泵電容、PREVGH、VSH、VSL、PREVGL |
| C4 | 4.7uF/10V | C 0402 1005Metric | 1 | MLCC 0402 X5R 10V | Samsung CL05A475MP5NRNC | C23733 Basic | 3V3 升壓輸入 |
| C6, C7, C8, C12 | 1uF/25V | C 0402 1005Metric | 4 | MLCC 0402 X5R 25V | Samsung CL05A105KA5NQNC | C52923 Basic | VDDIO / VCI（3V3）、VDD、VPP、VCOM |
| D1, D2, D3 | B5819WS | D SOD-323 | 3 | 蕭特基 SOD-323 40V 1A | MDD B5819WS | C64886 Ext（Preferred） | 負壓泵（PREVGL）、負壓泵（到 GND）、升壓整流（PREVGH） |
| Q1 | AO3400A | SOT-23 | 1 | N-MOSFET SOT-23 30V 5.7A（取代原廠 Si1308EDL） | AO3400A | C20917 Basic | 升壓開關（GDR 驅動） |
| R1 | 10k | R 0402 1005Metric | 1 | 0402 1% | UNI-ROYAL 0402WGF1002TCE | C25744 Basic | Q1 Gate 下拉 |

## 2. 手焊零件（自己買料）

| 編號 | 值 | 封裝 | 規格 | 型號 | LCSC（自購參考） | 用途 |
|---|---|---|---|---|---|---|
| J1 | AFC07-S24FCA-00 | Jushuo AFC07-S24FCA-00 1x24-1MP P0.50 Horizontal | FPC 0.5mm 24P 抽屜式 SMT，下接（Bottom Contact） | JUSHUO AFC07-S24FCA-00 | C262567 | 面板 FPC 座 |
| L1 | 10uH Isat>=1A | L 1008 2520Metric | 功率電感 2520(1008) 10uH，Isat 1.1A、480mΩ | Sunlord WPN252012H100MT | C98353 | 升壓電感 |
| R2 | 0.47R 1% | R 0402 1005Metric | 0402 1% 低阻（電流檢測） | UNI-ROYAL 0402WGF470LTCE | C423162 | RESE 電流檢測 |

焊接順序建議：先焊 **J1 FPC 座**（最難，0.5mm 間距：上助焊劑、對位後先固定兩端，再拖焊，用放大鏡檢查短路），再焊 R2、L1。

## 3. 另購

| 項目 | 規格 | 數量 | 備註 |
|---|---|---|---|
| 排線 | 8 芯細線（26–28 AWG），或剪一段 8P 杜邦線 | 1 | 手焊到 J2 焊點（2.0mm 間距穿孔，孔徑 0.8mm），另一端接 ESP32-C3；線序見 README |
| 電子紙 | GDEQ0426T82（4.26"，SSD1677，24pin 0.5mm FPC） | 1 | 換別的面板要先確認 RESE 值（本板固定 0.47Ω） |

## 4. 挑料注意

- **L1 電感**：選 Sunlord WPN252012H100MT（Isat 1.1A）。2520 的 10µH 很多款 Isat 不到 1A，缺料要換時要看規格書。
- **J1 FPC 座**：C262567 是**下接（Bottom Contact）**，要對照現有 DESPI-C02 的座子和面板金手指朝向，不合要換上接款；換別家要確認焊墊位置和 KiCad `Jushuo_AFC07-S24FCA-00` 一樣。
- **J2**：只是穿孔焊點，不貼片；想改插拔也可以焊 2.0mm 間距排針。
- **高壓電容（C1、C2、C3、C5、C9、C10、C11）**：腳位電壓約 ±20V，用 25V 以上；用 0805 是因為 JLC 的 4.7µF/25V 只有 0805 有 Basic 料（C1779），直流偏壓衰減也比 0603 小。
- **Q1**：原廠 Si1308EDL（SOT-323）換成 AO3400A（SOT-23，30V 5.7A），JLC Basic 料、電氣規格更寬裕。

## KiCad design battery_management/hardware/kicad_v2/C3_Battery_Backpack.kicad_pcb

File battery_management/hardware/kicad_v2/README.md:

# KiCad 版電池背板 v2（程式自動產生）

做法同 `switch_relay_Control/D1mini_Fixture_Shield_HW/kicad`：用 KiCad 10.0.7 的 Python 介面產生電路圖與 PCB，格點自動佈線（雙層 + 過孔），再用 `kicad-cli` 做 ERC / DRC 並匯出 Gerber。

## 結果

- **ERC：0 錯誤**（只有 7 個「自製 footprint 庫不在庫表」的提示）
- **DRC：0 錯誤、0 未連接**（同樣只剩 7 個自製 footprint 庫的提示）
- **電路圖網路表與 PCB 的 7 條網路逐條比對，完全一致**
- **v2.1**：板子 **12.0 × 12.8 mm**（v2.0 為 13.6 × 18.8 mm，面積少 40%）、**板厚 0.6 mm**、雙層 1 oz
  - 實板 USB-C 固定腳焊點是平的，取消 v2.0 的缺口與圓孔，板框為單純矩形
- 走線 35 段、過孔 8 個（0.6 / 0.3 mm）
  - 線寬：VBAT 0.5 mm；VBUS、VSYS、GND 0.4 mm；訊號 0.25 mm
  - 兩面鋪 GND
- 設計規則（寫在 `C3_Battery_Backpack.kicad_pro`）：
  - 線寬 / 線距 ≥ 0.15 mm
  - 銅箔到板框 ≥ 0.3 mm（JLCPCB 能力 0.2 mm）
  - 絲印字高 0.8 mm、筆畫 0.15 mm

## BOM

零件清單：[`BOM.md`](BOM.md)；手焊組裝圖（零件編號、Pin 1）：[`ASSEMBLY.png`](ASSEMBLY.png)

## 電路圖

- PDF：[`C3_Battery_Backpack_schematic.pdf`](C3_Battery_Backpack_schematic.pdf)
- 圖檔：[`C3_Battery_Backpack_schematic.png`](C3_Battery_Backpack_schematic.png)（向量檔 [`.svg`](C3_Battery_Backpack_schematic.svg)）

## 給板廠的檔案

**`C3_Battery_Backpack_v2.1_Gerber.zip`**：直接上傳 JLCPCB。內含：

| 檔案 | 內容 |
|---|---|
| `*-F_Cu.gtl` / `*-B_Cu.gbl` | 頂層 / 底層銅箔 |
| `*-F_Mask.gts` / `*-B_Mask.gbs` | 防焊 |
| `*-F_Silkscreen.gto` / `*-B_Silkscreen.gbo` | 絲印 |
| `*-Edge_Cuts.gm1` | 板框（12.0 × 12.8 mm 矩形） |
| `*.drl` | 鑽孔（過孔，Excellon，mm） |
| `*-job.gbrjob` | 工作檔 |

### 下單參數（JLCPCB）

| 項目 | 設定 |
|---|---|
| Base Material / Layers | FR-4，2 層 |
| Dimensions | 12 × 12.8 mm（上傳 Gerber 後會自動帶入） |
| **PCB Thickness** | **0.6 mm** |
| Surface Finish | LeadFree HASL（無鉛噴錫） |
| Outer Copper Weight | 1 oz |
| 其他 | 綠漆白字；其餘預設 |

2026-10-23 線上報價（v2.0 尺寸）：5 片約 **US$5.5**（不含運費）；v2.1 更小，價格應相同或更低。

- 0.4 mm 板厚只能選 ENIG 或 OSP，報價會跳到 US$33–50，所以改用 0.6 mm。
- 下單前請在 JLCPCB 的 Gerber Viewer 再看一次板框。

### 實板核對（2026-10-23，依背面照片以排針間距 2.54 mm 換算，精度約 ±0.3 mm）

座標為 SuperMini 背面、USB 朝上、板子左上角為原點（mm）。

| 項目 | 實板（照片推算） | v2.1 的處理 |
|---|---|---|
| USB-C 固定腳（橢圓鍍銅孔，約 1.1 × 1.6） | (4.7, 1.0)、(13.3, 1.0)、(4.7, 5.2)、(13.3, 5.2)，**焊點平整不凸起** | 取消 v2.0 的 U 形缺口與圓孔，背板直接蓋過去 |
| 5V / G 排針中心 | y ≈ 1.4 / 3.9 | P1、P2 放在同高度，跳線最短 |
| GPIO0 排針中心 | y ≈ 19.1 | P4 在背板下緣（y = 12.5），跳線約 7 mm |
| GPIO20 排針中心（右排） | y ≈ 16.6 | P3（y = 11.0）的 CHRG 線橫越背板到右排，約 15 mm，用絕緣線 |
| 板長 | 約 22–22.5 | 背板下緣 y = 13.3，離天線區很遠 |

背板放在 SuperMini 背面 (3.0, 0.5)，左右緣 x = 3.0 / 15.0，距排針焊錫凸點（約 x = 2.5 / 15.5）約 0.5 mm。

外形與位置圖：[`../../docs/BACKPACK_V2_PCB_OUTLINE.png`](../../docs/BACKPACK_V2_PCB_OUTLINE.png)（`python gen_outline.py` 產生）。

## 板上接點

| 接點 | 絲印 | 網路 | 接到 |
|---|---|---|---|
| P1 | 5V | VBUS | SuperMini 5V 焊墊（同高度，短跳線） |
| P2 | G | GND | SuperMini G 焊墊（同高度，短跳線） |
| P3 | IO1（絲印） | CHRG | **GPIO20**（右排第 7 根，絕緣線約 15 mm）。2026-10-31 由 GPIO1 改過來，GPIO1 留給 deep sleep 喚醒按鈕；絲印沒改 |
| P4 | IO0 | VBAT/2 | GPIO0（跳線約 7 mm） |
| P5 | （右上，無字） | VSYS | 飛線到正面 W5 的 A 端 |
| P6 | B+ | VBAT | 電池 + |
| P7 | B- | GND | 電池 − |

零件代號沒有印在板上（板子太小），手焊時對照 [`ASSEMBLY.png`](ASSEMBLY.png)。

背面絲印「SUPERMINI SIDE」，表示這面貼 SuperMini。

## 重新產生

```bash
python gen_sch.py
"D:\Program Files\KiCad\bin\python.exe" build_pcb.py --route
"D:\Program Files\KiCad\bin\kicad-cli.exe" sch erc --format json --severity-all -o erc.json C3_Battery_Backpack.kicad_sch
"D:\Program Files\KiCad\bin\kicad-cli.exe" pcb drc --format json --severity-all -o drc.json C3_Battery_Backpack.kicad_pcb
"D:\Program Files\KiCad\bin\kicad-cli.exe" pcb export gerbers -o gerber --layers F.Cu,B.Cu,F.Mask,B.Mask,F.Silkscreen,B.Silkscreen,Edge.Cuts C3_Battery_Backpack.kicad_pcb
"D:\Program Files\KiCad\bin\kicad-cli.exe" pcb export drill -o gerber/ --format excellon --excellon-units mm C3_Battery_Backpack.kicad_pcb
python gen_outline.py
"D:\Program Files\KiCad\bin\python.exe" gen_assembly.py   # ASSEMBLY.svg，PNG 用下面的 Edge 指令截圖
"D:\Program Files\KiCad\bin\kicad-cli.exe" sch export pdf -o C3_Battery_Backpack_schematic.pdf C3_Battery_Backpack.kicad_sch
"D:\Program Files\KiCad\bin\kicad-cli.exe" sch export svg -o . C3_Battery_Backpack.kicad_sch   # 輸出 C3_Battery_Backpack.svg，改名為 C3_Battery_Backpack_schematic.svg
```

PNG 用 Edge headless 把 SVG 截圖（2 倍解析度）：

```bash
msedge --headless=new --force-device-scale-factor=2 --window-size=1123,794 --screenshot=C3_Battery_Backpack_schematic.png file:///<完整路徑>/C3_Battery_Backpack_schematic.svg
```

| 檔案 | 用途 |
|---|---|
| `geom.py` | 板子尺寸、板厚、在 SuperMini 上的位置（共用） |
| `gen_outline.py` | 產生 `docs/BACKPACK_V2_PCB_OUTLINE.svg`（外形與位置圖） |
| `gen_sch.py` | 產生電路圖 `C3_Battery_Backpack.kicad_sch` |
| `build_pcb.py` | 放零件、接點 footprint、網路、板框、絲印 |
| `route.py` | 自動佈線（A* 格點、雙層）與兩面鋪 GND |
| `erc.json` / `drc.json` | 最近一次 ERC / DRC 報告 |
| `gerber/` | Gerber 與鑽孔原始輸出 |
| `gen_assembly.py` / `ASSEMBLY.svg` / `ASSEMBLY.png` | 手焊組裝圖 |
| `C3_Battery_Backpack_schematic.pdf` / `.png` / `.svg` | 電路圖輸出 |
| `render_top.png` / `render_bottom.png` / `top.svg` / `bottom.svg` | PCB 預覽 |

Board: 2 copper layers, 12.0 x 12.8 mm, 17 parts (0 on the bottom side), 7 nets.

Parts:
C1: 1uF; C_0603_1608Metric
C2, C3: 10uF; C_0805_2012Metric
C4: 100nF; C_0603_1608Metric
P1: P1; EdgePad_0.7x1.0
P2: P2; EdgePad_0.7x1.0
P3: P3; EdgePad_0.7x1.0
P4: P4; EdgePad_0.7x1.0
P5: P5; EdgePad_0.7x1.0
P6: P6; EdgePad_0.7x1.0
P7: P7; EdgePad_0.7x1.0
Q1: AO3401; SOT-23
R1: 100k; R_0603_1608Metric
R2: 5.1k; R_0603_1608Metric
R3, R4: 1M; R_0603_1608Metric
U1: TP4054; SOT-23-5

Connections:
CHRG: P3.1, U1.1
GND: C1.2, C2.2, C3.2, C4.2, P2.1, P7.1, R1.2, R2.2, R4.2, U1.2
PROG: R2.1, U1.5
VBAT: C2.1, P6.1, Q1.3, R3.1, U1.3
VBAT_SENSE: C4.1, P4.1, R3.2, R4.1
VBUS: C1.1, P1.1, Q1.1, R1.1, U1.4
VSYS: C3.1, P5.1, Q1.2

## Code that names these connections

File EPD24_SuperMini_Adapter_HW/kicad/build_pcb.py (part):

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        左排 = 5V G 3V3 IO4 IO3 IO2 IO1 IO0，右排 = IO5 IO6 IO7 IO8 IO9 IO10 IO20 IO21（上到下）。
電路：  照 Good Display DESPI-C02 原理圖（SCH V1.0）；RESE 固定 0.47Ω、BS 直接接地（4 線 SPI）。
v1.1：  併入電池背板 v2.1 的電路（battery_management/hardware/kicad_v2）：TP4054 充電、AO3401 load-sharing、
        1M/1M 分壓 → GPIO0、CHRG → GPIO20；電池焊墊 B+ / B−，VSYS 焊墊飛線到 Super Mini 正面 W5 的 A 端。
腳位：  GPIO0~5 留給 ADC 與 deep sleep 喚醒：VBAT/2 → IO0，喚醒按鍵 K1 → IO1、K2 → IO3（100k 上拉、按下接地）；
        SDI 改走 IO7（C3 原生 FSPID），CHRG 改走 IO20。
"""
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
# 左半：面板電源腳的電容（FPC pin 15~24 在左邊）
for ref, fpn, val, x, y, rot in (
        ("C12", C0402, "1uF/25V", 3.5, 8.2, 0),       # VCOM (pin 24)
        ("C8", C0402, "1uF/25V", 5.45, 8.2, 0),       # VPP (pin 19)
        ("C6", C0402, "1uF/25V", 7.4, 8.2, 0),        # VDDIO/VCI 3V3 (pin 15/16)
        ("C10", C0603, "4.7uF/25V", 4.0, 9.9, 0),     # VSL (pin 22)
        ("C7", C0402, "1uF/25V", 6.6, 9.9, 0),        # VDD (pin 18)
        ("C9", C0603, "4.7uF/25V", 4.0, 11.6, 0),     # VSH (pin 20)
        ("C11", C0603, "4.7uF/25V", 4.0, 13.3, 0),    # PREVGL (pin 23)
        ("C5", C0603, "4.7uF/25V", 4.0, 15.0, 0),     # PREVGH (pin 21)
        ("C4", C0402, "4.7uF/10V", 6.6, 11.6, 0),     # 3V3 升壓輸入
):
    fps[ref] = place(fp_lib(*fpn), ref, val, x, y, rot)

# 右半：VGH / VGL 電容與升壓電路（FPC pin 2~5 在右邊）
for ref, fpn, val, x, y, rot in (
        ("C2", C0603, "4.7uF/25V", 12.3, 8.9, -90),    # VGH (pin 5)
        ("C1", C0603, "4.7uF/25V", 14.1, 8.9, -90),    # VGL (pin 4)
        ("R1", R0402, "10k", 14.4, 11.6, 0),          # GDR 下拉
        ("R2", R0402, "0.47R 1%", 14.4, 13.0, 0),     # RESE 電流檢測
        ("C3", C0603, "4.7uF/25V", 12.5, 20.2, 0),    # 負壓泵電容
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fps["Q1"] = place(fp_lib("Package_TO_SOT_SMD", "SOT-323_SC-70"), "Q1", "Si1308EDL", 11.9, 12.3, 0)
fps["L1"] = place(fp_lib("Inductor_SMD", "L_1008_2520Metric"), "L1", "10uH Isat>=1A", 12.5, 15.6, 0)
SOD = ("Diode_SMD", "D_SOD-323")
fps["D3"] = place(fp_lib(*SOD), "D3", "B5819WS", 12.5, 18.3, 180)   # SW → PREVGH（pin 1 = 陰極）
fps["D1"] = place(fp_lib(*SOD), "D1", "B5819WS", 12.5, 22.1, 0)     # PREVGL → NEG
fps["D2"] = place(fp_lib(*SOD), "D2", "B5819WS", 12.5, 24.1, 180)   # NEG → GND

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fps["U2"] = place(fp_lib("Package_TO_SOT_SMD", "SOT-23-5"), "U2", "TP4054", 4.6, 22.7, 0)
fps["Q2"] = place(fp_lib("Package_TO_SOT_SMD", "SOT-23"), "Q2", "AO3401A", 8.7, 22.7, 0)
for ref, fpn, val, x, y, rot in (
        ("R4", R0402, "5.1k", 6.0, 20.2, 0),          # PROG：充電 196mA，≥ 400mAh 電池；小電池改 10k（貼著 U2 pin 5）
        ("C13", C0402, "1uF/10V", 8.85, 17.9, 90),    # TP4054 VCC（不要加大，會拖慢切換）
        ("R3", R0402, "100k", 9.95, 17.9, 90),        # Q2 Gate 下拉
        ("C15", C0603, "22uF/10V", 8.6, 20.0, 0),     # VSYS，WiFi 尖峰補強
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
## Commit log (part)

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2025-10-27 Initial commit: ESP32-C3 projects with E-Paper display driver
2025-10-29 Add ESP32-C3 WiFi E-Paper Display project with WebSocket client
    Features:
    - UDP server auto-discovery (port 8888)
    - WebSocket client for binary protocol
    - Binary packet protocol with fragmentation handling
    - Tile-based partial update (800x480 split to 3x 800x160)
    - Full-screen update mode with screen clearing
2025-10-31 refactor: optimize to full-screen mode and fix ghosting issue
    - Remove tile mode (deprecated), use full-screen mode only
    - Fix ghosting: clear screen before every full-screen update
    - Memory optimization: remove unused buffers (save 36KB)
    * Remove image_buffer (20KB)
    * Remove tile_buffer (16KB)
    * Increase packet_buffer to 50KB for full-frame reception
2025-12-18 Add battery management system design for ESP32-C3 SuperMini - TP4054 + MOSFET charging solution with 3-6 month battery life
2026-01-06 更新電池管理文件：統一使用 TP4054/AO3401/2N7002 元件規格
    - 簡化 README.md BOM 清單，移除替代型號選項
    - 明確標注 TP4054 充電 IC (4.2V 1%)
    - 明確標注 AO3401 P-MOSFET (理想二極體，壓降 0.02V)
    - 明確標注 2N7002 N-MOSFET (省電 ADC，平時 0μA)
    - 更新 SUPERMINI_BATTERY_DESIGN.md 添加詳細規格說明
    - 確保所有文件使用一致的元件型號
2026-01-06 新增 ESP32-C3 參考文件
    - ESP32-C3 SuperMini 原理圖 (schematic)
    - ESP32-C3 SuperMini 規格書 (ArtronShop)
    - ESP32-C3 技術參考手冊 (官方)
    - ESP32-C3 數據手冊 (官方)
    - ESP32-C3 SuperMini 腳位圖 (正面/背面)
2026-01-09 改進 W5/PD1 設計：只斷開 VSYS 端，保留充電保護
    主要變更：
    - W5 改造方式：只斷開 VSYS 端，保留 USB 端連接
    - 優勢：保留 TP4054 充電路徑的反向保護，電池供電繞過 W5 高效率
    - AO3401 Gate 改接 TP4054 VCC（透過 W5），簡化接線
    - 新增三種改造方法：抬起單端（推薦）、切斷走線、完全移除
    - 更新 W5_PD1_REMOVAL_GUIDE.md 為改造指南
2026-01-09 新增 Mermaid 電路圖至 WIRING_DIAGRAM.md
    改進視讀性：
    - Step 1: TP4054 充電 IC 連接圖
    - Step 2: AO3401 P-MOSFET 自動切換圖（顯示工作狀態）
    - Step 3: 2N7002 N-MOSFET 省電 ADC 圖（顯示省電/測量模式）
    - Step 4: 穩定電容連接圖
    所有圖表使用彩色標註，清楚顯示元件功能與電路工作原理
2026-01-09 調整電池容量為 500mAh 並優化充電參數
    主要變更：
    - 電池容量：1200mAh 500mAh
    - 充電電流：333mA (3kΩ) 130mA (10kΩ)
    - 充電率：0.3C-0.5C 0.26C (更安全)
    - 充電時間：3.6小時 3.8小時
    - 續航時間：290天 121天 (實際 2-3個月)
2026-01-09 新增 TP4054 + AO3401 綜合電路圖
    改進：
    - 合併 Step 1 和 Step 2 為單一 Mermaid 圖表
    - 分為兩大區域：
    1. ESP32-C3 SuperMini 板子改造區（紅色邊框）
    2. 新增 TP4054 + AO3401 電路（綠色邊框）
    - 子區塊：
2026-01-09 新增 WIRING_DIAGRAM.md 綜合電路架構圖
    改進：
    - 在詳細接線步驟前新增整體電路架構圖
    - 合併 Step 1 (TP4054) 和 Step 2 (AO3401) 為單一視圖
    - 分為兩大區域：
    1. ESP32-C3 SuperMini 板子改造區（紅色邊框）
    2. 新增 TP4054 + AO3401 電路（綠色邊框）
2026-01-09 改進電池標示：明確標註正負極
    改進項目：
    - 所有 Mermaid 圖中的電池加上正負極標示
    - 整體架構圖：電池標示 (+) 正極 / (-) 負極
    - Step 1-4 各步驟圖：清楚顯示正負極連接
    - 系統架構文字圖：加入正負極標記
    - 使用 🔋 emoji 增強辨識度
2026-01-09 新增模組化視圖：電池管理模組（黑盒設計）
    新增功能：
    - 將 TP4054 + AO3401 + 電池封裝為獨立模組
    - 對外只暴露 3 個接口：
    1. USB 5V (透過 W5) - 輸入
    2. VSYS - 輸出
    3. GND - 接地
2026-01-09 電池管理模組：新增詳細引腳和電阻接線圖
2026-01-09 優化電池管理模組圖表：採用 LR 橫向布局減少連線交叉
2026-01-09 電路圖新增線條圖例：🔧 粗線表示需焊接的實體線，虛線表示IC內部連接
2026-01-09 修正電路圖：1.移除TP4054內部連線 2.AO3401 Gate接USB 5V輸入點 3.電阻移到IC框外
2026-01-09 新增元件規格書：TP4054/AO3401/2N7002 PDF 和圖片
2026-01-09 調整IC引腳位置符合實際封裝：TP4054上排(PROG/VCC)下排(GND/NC/BAT)，AO3401左側(Gate/Source)右側(Drain)
2026-01-09 修正IC引腳位置：TP4054上排(5NC/4VCC)下排(1GND/2PROG/3BAT)，AO3401左上(G)右中(D)左下(S)
2026-01-11 Initial plan
2026-01-11 Update README with comprehensive project documentation and usage guide
2026-01-11 Update battery management design to keep PD1/W5 intact
2026-01-11 Fix code review issues: voltage range and variable references
2026-01-12 修正TP4054引腳標註：Pin5(PROG) Pin4(VCC) Pin1(CHRG) Pin2(GND) Pin3(BAT)
2026-01-16 優化電池管理佈局說明：添加 mermaid 物理佈局圖，展示 TP4054(Pin5/4上 Pin1/2/3下) 和 AO3401(右轉90度) 的優化配置
2026-01-16 修正整體電路架構圖：正確排列為左(電池)中(TP4054)右(AO3401)，ESP32板在上方
